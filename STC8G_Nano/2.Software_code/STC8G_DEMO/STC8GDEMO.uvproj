# Keil uVision project STC8GDEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: STC8GDEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\MY
  group MIAN
    ./: STARTUP.A51 mian.c
  group MY
    ./MY/: GPIO.c oled.c WS2812B.c UART.C Exti.c
